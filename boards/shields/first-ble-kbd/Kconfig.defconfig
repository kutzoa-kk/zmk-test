## boards/shields/first-ble-kbd/Kconfig.defconfig
```kconfig
if SHIELD_FIRST_BLE_KBD

config ZMK_KEYBOARD_NAME
    default "First BLE KBD"

endif
```
